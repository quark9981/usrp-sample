options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: frequency
  id: variable
  parameters:
    value: 36e6
  states: {state: disabled}
- name: frequency
  id: variable
  parameters:
    value: 315e6
  states: {state: disabled}
- name: frequency
  id: variable
  parameters:
    value: 915e6
  states: {state: disabled}
- name: frequency
  id: variable
  parameters:
    value: 868e6
  states: {state: disabled}
- name: frequency
  id: variable
  parameters:
    value: 433e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /tmp/key.raw
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: ''
    bb_gain0: '20'
    freq0: frequency
    gain0: '20'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    label2: ''
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: frequency
    dev_args: '""'
    gain0: '0'
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_file_source_0, '0', osmosdr_sink_0, '0']
- [blocks_file_source_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_file_source_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_file_source_0, '0', uhd_usrp_sink_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
